V1 1 0 0 0 1 0 0 0
I1 2 0 0 0 1e-3 0 0 0
N1 1 0 2 0 10e3 100 320 0
.pr 0 0 0 0 0 0 0 0
.op 0 0 0 0 0 0 0 0
